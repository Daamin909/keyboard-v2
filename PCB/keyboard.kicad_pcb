# Repository Daamin909/keyboard-v2

File README.md:

# keyboard - v2

Made by [Daamin](https://daamin.tech)

Features:

- 61x keys!
- Default 60% Layout
- 2x EC11 Rotary Encoder - For Volume, Brightness etc
- 9x LEDs with acrylic for aesthetics (multicolor)
- COOOL Silkscreen
- 5° inclined case
- Comfy Design
- KMK firmware

## Info

I made this keyboard since I wanted a compact alternative to my bigger keyboard, this keyboard is pretty small in size and has most of the necessary keys. I also wanted to make this one look aesthetically pleasing instead of my old keyboard which did not look really good 😭.

It has 9x LEDs, out of which 3 are Red, Blue and Green. I did not use neopixels since PCBA is a bit expensive, and SMD soldering is out of my league for now.

In order to mount the acrylic sheet that is on top of the cutout, I designed a 3D printed part that will be super glued to hold it in place.

I will be using a cool green gradient keycaps, which will blend really well with the white case and the black PCB. The PCB will be visible from the LED cutout. The silkscreen also looks very good and is Harry Potter Themed.

## PCB

The PCB's size is 290.9mm x 123.4mm

| Schematic                 |
| ------------------------- |
|  |

| Front                 |
| --------------------- |
|  |

| Back                 |
| -------------------- |
|  |

| 3D - Front               |
| ------------------------ |
|  |

| 3D - Back               |
| ----------------------- |
|  |

## Case

The case was made in Fusion360.
The last image is of the 3D printed part to hold the acrylic sheet in place.
I chose to add branding on the bottom case only for aesthetics.

## 3D Render:

## Layout:

The Layout is a Default 60%.

## BOM

| Name                                                                  | Qty | Final Price - INR (USD) | Link                                                                                                                |
| --------------------------------------------------------------------- | --- | ----------------------- | ------------------------------------------------------------------------------------------------------------------- |
| Gateron EF Grayish                                                    | 70  | 1465 ($17.14)           | [here](https://neomacro.in/products/gateron-ef-grayish)                                                             |
| Cherry Profile PBT Keycaps                                            | 1   | 1299 ($15.14)           | [here](https://stackskb.com/store/veekos-gradient-keycaps-cherry-profile-135-keys)                                  |
| Durock Smokey Screw-In Stabilizers V2 (4+1 w/ 6.25u spacebar)         | 1   | 1595 ($18.6)            | [here](https://stackskb.com/store/durock-smokey-screw-in-stabilizers-v2/)                                           |
| Diode 1N4148 Through - Hole                                           | 80  | 188.8 ($2.21)           | [here](https://roboticsdna.in/product/diode-1n4148/)                                                                |
| EC11 Rotary Encoder                                                   | 2   | 178 ($2.08)             | [here](https://amzn.in/d/hVRxzij)                                                                                   |
| M3 x 16mm Bolt                                                        | 10  | 124 ($1.44)             | [here](https://amzn.in/d/0eY6kT4)                                                                                   |
| M3 x 25mm Bolt                                                        | 10  | 145 ($1.69)             | [here](https://amzn.in/d/3zS0SJ2)                                                                                   |
| M3 x 4mm Heatset Insert                                               | 25  | 242 ($2.83)             | [here](https://amzn.in/d/dpL3N2a)                                                                                   |
| PCB - (Black Color)                                                   | 5   | 3802.44 ($44.5)         | [here](https://hc-cdn.hel1.your-objectstorage.com/s/v3/3f05c160f070155d4d5333c6b8261f5120b33c4c_image.png)          |
| Raspberry Pi Pico                                                     | 1   | 366.01 ($4.28)          | [here](https://roboticsdna.in/product/raspberry-pi-pico/)                                                           |
| Super Bright Red LED 5MM (5 Pieces)                                   | 2   | 48 ($0.56)              | [here](https://roboticsdna.in/product/super-bright-red-led-5mm-5-pieces/)                                           |
| Super Bright Blue LED 5MM (5 Pieces)                                  | 2   | 30 ($0.35)              | [here](https://roboticsdna.in/product/super-bright-blue-led-5mm-5-pieces/)                                          |
| Super Bright Green LED 5MM (5 Pieces)                                 | 2   | 24 ($0.28)              | [here](https://roboticsdna.in/product/super-bright-green-led-5mm-5-pieces/)                                         |
| 330K Ohm 0.25W CFR Resistor ±5% Tolerance (Pack of 50 )               | 1   | 29.5 ($0.35)            | [here](https://roboticsdna.in/product/330k-ohm-0-25w-cfr-resistor-%c2%b15-tolerance-pack-of-50/)                    |
| Acrylic Sheet                                                         | 1   | 240 ($2.81)             | [here](https://amzn.in/d/05dUxqd)                                                                                   |
| Top Case - 1 (White "./production/top.step")                          | 1   | 2582 ($29.89)           | [from 3ding.in](https://hc-cdn.hel1.your-objectstorage.com/s/v3/a1089c5d17e005a69043bc950fa28f1e25543591_image.png) |
| Rotary Encoder Knob                                                   | 2   | Print Legion            |
| Bottom Case - 1 (White "./production/bottom.step")                    | 1   | Print Legion            |
| Acrylic Sheet Mount - 1 (White "./production/acrylic-sheet-lid.step") | 1   | Print Legion            |

## Total Pricing

The keyboard comes out to be approximately 12,300 INR ($142.38) when adding ordered parts and PCB. Does not include 3D - Printed case and Knob.
PS:- (Seed Studio costs $142 )
I have chose "air registered mail" over "UPS World Saver" because air registered mail is less likely to get customs even if it is more expensive.

## Notes :-

I want all the three 3D-printed parts to be printed in white color.

Some of the above items, were ordered in packs due to unavailability of singular items.
The pricing might slightly vary due to flash sales, and dollar market trends.

## KiCad design PCB/keyboard.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D64, D65, D66, D67, D68, D69, D70, D71, D72: LED_Small; LED_D5.0mm
R1, R2, R3: 330Ω; R_Axial_DIN0309_L9.0mm_D3.2mm_P20.32mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52: SW_Push; SW_Cherry_MX_1.00u_PCB
SW14: SW_Push; SW_Cherry_MX_2.00u_PCB
SW15, SW28: SW_Push; SW_Cherry_MX_1.50u_PCB
SW29: SW_Push; SW_Cherry_MX_1.75u_PCB
SW41, SW42: SW_Push; SW_Cherry_MX_2.25u_PCB
SW53: SW_Push; SW_Cherry_MX_2.75u_PCB
SW54, SW55, SW56, SW58, SW59, SW60, SW61: SW_Push; SW_Cherry_MX_1.25u_PCB
SW57: SW_Push; SW_Cherry_MX_6.25u_PCB
SW62, SW63: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMoun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
U1: Pico; RPi_Pico_SMD_TH

Connections:
GND: R1.2, R2.2, R3.2, SW62.C, SW63.C, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.S1
unnamed: D63.2 (A), SW63.S1
unnamed: D64.1 (K), D65.1 (K), D66.1 (K), R1.1
unnamed: D67.1 (K), D68.1 (K), D69.1 (K), R2.1
unnamed: D70.1 (K), D71.1 (K), D72.1 (K), R3.1
blue_anode: D67.2 (A), D68.2 (A), D69.2 (A), U1.34 (GPIO28_ADC2)
col1: SW1.1, SW15.1, SW29.1, SW42.1, SW54.1, U1.1 (GPIO0)
col2: SW2.1, SW16.1, SW30.1, SW43.1, SW55.1, U1.2 (GPIO1)
col3: SW3.1, SW17.1, SW31.1, SW44.1, SW56.1, U1.4 (GPIO2)
col4: SW4.1, SW18.1, SW32.1, SW45.1, SW57.1, U1.5 (GPIO3)
col5: SW5.1, SW19.1, SW33.1, SW46.1, SW58.1, U1.6 (GPIO4)
col6: SW6.1, SW20.1, SW34.1, SW47.1, SW59.1, U1.7 (GPIO5)
col7: SW7.1, SW21.1, SW35.1, SW48.1, SW60.1, U1.9 (GPIO6)
col8: SW8.1, SW22.1, SW36.1, SW49.1, SW61.1, U1.10 (GPIO7)
col9: SW9.1, SW23.1, SW37.1, SW50.1, U1.11 (GPIO8)
col10: SW10.1, SW24.1, SW38.1, SW51.1, U1.12 (GPIO9)
col11: SW11.1, SW25.1, SW39.1, SW52.1, U1.14 (GPIO10)
col12: SW12.1, SW26.1, SW40.1, SW53.1, U1.15 (GPIO11)
col13: SW13.1, SW27.1, SW41.1, U1.16 (GPIO12)
col14: SW14.1, SW28.1, SW62.S2, SW63.S2, U1.17 (GPIO13)
green_anode: D70.2 (A), D71.2 (A), D72.2 (A), U1.31 (GPIO26_ADC0)
re1: SW62.B, U1.25 (GPIO19)
re2: SW62.A, U1.26 (GPIO20)
re3: SW63.B, U1.27 (GPIO21)
re4: SW63.A, U1.29 (GPIO22)
red_anode: D64.2 (A), D65.2 (A), D66.2 (A), U1.32 (GPIO27_ADC1)
row1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U1.19 (GPIO14)
row2: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U1.20 (GPIO15)
row3: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D62.1 (K), U1.21 (GPIO16)
row4: D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D63.1 (K), U1.22 (GPIO17)
row5: D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), U1.24 (GPIO18)

Board: 2 copper layers, 290.9 x 123.4 mm, 139 parts (66 on the bottom side), 93 nets.

File PCB/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D4, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D5, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D6, D60, D61, D62, D63, D7, D8, D9",D_DO-35_SOD27_P7.62mm_Horizontal,63,1N4148,
"D64, D65, D66, D67, D68, D69, D70, D71, D72",LED_D5.0mm,9,LED_Small,
"R1, R2, R3",R_Axial_DIN0309_L9.0mm_D3.2mm_P20.32mm_Horizontal,3,330Ω,
"SW1, SW10, SW11, SW12, SW13, SW16, SW17, SW18, SW19, SW2, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW3, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW4, SW40, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW5, SW50, SW51, SW52, SW6, SW7, SW8, SW9",SW_Cherry_MX_1.00u_PCB,46,SW_Push,
SW14,SW_Cherry_MX_2.00u_PCB,1,SW_Push,
"SW15, SW28",SW_Cherry_MX_1.50u_PCB,2,SW_Push,
SW29,SW_Cherry_MX_1.75u_PCB,1,SW_Push,
"SW41, SW42",SW_Cherry_MX_2.25u_PCB,2,SW_Push,
SW53,SW_Cherry_MX_2.75u_PCB,1,SW_Push,
"SW54, SW55, SW56, SW58, SW59, SW60, SW61",SW_Cherry_MX_1.25u_PCB,7,SW_Push,
SW57,SW_Cherry_MX_6.25u_PCB,1,SW_Push,
"SW62, SW63",RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMountingHoles,2,RotaryEncoder_Switch,
U1,RPi_Pico_SMD_TH,1,Pico,

## Code that names these connections

File firmware/code.py:

# Daamin's keyboard-v2 firmware
# Rev 1.3
# Copyright 2024
# Licensed under zlib license

import board
import busio
import digitalio
from kmk.kmk_keyboard import KMKKeyboard
from kmk.keys import KC
from kmk.scanners import DiodeOrientation
from kmk.modules.encoder import EncoderHandler
from kmk.extensions.media_keys import MediaKeys
from kmk.modules.mouse_keys import MouseKeys
from kmk.modules.layers import Layers
from kmk.modules.macros import Macros

# Pin definitions
ROT1A = board.GP19
ROT1B = board.GP20
ROT2A = board.GP22
ROT2B = board.GP21
COL1 = board.GP0
COL2 = board.GP1
COL3 = board.GP2
COL4 = board.GP3
COL5 = board.GP4
COL6 = board.GP5
COL7 = board.GP6
COL8 = board.GP7
COL9 = board.GP8
COL10 = board.GP9
COL11 = board.GP10
COL12 = board.GP11
COL13 = board.GP12
COL14 = board.GP13
ROW1 = board.GP14
ROW2 = board.GP15
ROW3 = board.GP16
ROW4 = board.GP17
ROW5 = board.GP18

# Layer definitions
LAYER_BASE = 0
LAYER_ALT = 1

keyboard = KMKKeyboard()
encoder_handler = EncoderHandler()
encoder_handler2 = EncoderHandler()
macros = Macros()

keyboard.extensions.append(MediaKeys())
keyboard.extensions.append(MouseKeys())
keyboard.modules.append(Layers())
keyboard.modules.append(encoder_handler)
keyboard.modules.append(encoder_handler2)
keyboard.modules.append(macros)

# Encoders
encoder_handler.pins = ((ROT1A, ROT1B, None),)
encoder_handler.map = [
    ((KC.UP, KC.DOWN),),    # Layer 1: Up / Down Arrow
    ((KC.VOLD, KC.VOLU),),  # Layer 0: Volume Up / Down
]

encoder_handler2.pins = ((ROT2A, ROT2B, None),)
encoder_handler2.map = [
    ((KC.RIGHT, KC.LEFT),), # Layer 1: Left / Right Arrow
    ((KC.MFFD, KC.MRWD),),  # Layer 0: Media Rewind / Fast Forward
]

keyboard.col_pins = (COL1, COL2, COL3, COL4, COL5, COL6, COL7, COL8, COL9, COL10, COL11, COL12, COL13, COL14)
keyboard.row_pins = (ROW1, ROW2, ROW3, ROW4, ROW5)
keyboard.diode_orientation = DiodeOrientation.COL2ROW

numero_uno = KC.TO(LAYER_ALT)
numero_dos = KC.TO(LAYER_BASE)

# LED control pins
led1 = digitalio.DigitalInOut(board.GP26)
led1.direction = digitalio.Direction.OUTPUT
led2 = digitalio.DigitalInOut(board.GP27)
led2.direction = digitalio.Direction.OUTPUT
led3 = digitalio.DigitalInOut(board.GP28)
led3.direction = digitalio.Direction.OUTPUT

led1.value = False
led2.value = False
led3.value = False

# Keymaps
keyboard.keymap = [
    # Layer 0 - Base Layer
    [
        KC.ESC,  KC.N1,   KC.N2,   KC.N3,   KC.N4,   KC.N5,   KC.N6,   KC.N7,   KC.N8,   KC.N9,   KC.N0,   KC.MINS, KC.EQL,  KC.BSPC,
        KC.TAB,  KC.Q,    KC.W,    KC.E,    KC.R,    KC.T,    KC.Y,    KC.U,    KC.I,    KC.O,    KC.P,    KC.LBRC, KC.RBRC, KC.BSLS,
        KC.CAPS, KC.A,    KC.S,    KC.D,    KC.F,    KC.G,    KC.H,    KC.J,    KC.K,    KC.L,    KC.SCLN, KC.QUOT, KC.ENT,  KC.MUTE,
        KC.LSFT, KC.Z,    KC.X,    KC.C,    KC.V,    KC.B,    KC.N,    KC.M,    KC.COMM, KC.DOT,  KC.SLSH, KC.RSFT, KC.NO, KC.MEDIA_PLAY_PAUSE,
        KC.LCTL, KC.LALT, KC.LGUI, KC.SPC,  KC.LGUI, KC.RALT, KC.RCTL, numero_uno,   KC.NO,   KC.NO,   KC.NO,   KC.NO,   KC.NO,   KC.NO,
    ],
    # Layer 1 - Alternate Layer
    [
        KC.GRAVE,  KC.N1,   KC.N2,   KC.N3,   KC.N4,   KC.N5,   KC.N6,   KC.N7,   KC.N8,   KC.N9,   KC.N0,   KC.MINS, KC.EQL,  KC.BSPC,
        KC.TAB,    KC.Q,    KC.W,    KC.E,    KC.R,    KC.T,    KC.Y,    KC.U,    KC.I,    KC.O,    KC.P,    KC.LBRC, KC.RBRC, KC.BSLS,
        KC.CAPS,   KC.A,    KC.S,    KC.D,    KC.F,    KC.G,    KC.H,    KC.J,    KC.K,    KC.L,    KC.SCLN, KC.QUOT, KC.ENT,  KC.MUTE,
        KC.LSFT,   KC.Z,    KC.X,    KC.C,    KC.V,    KC.B,    KC.N,    KC.M,    KC.COMM, KC.DOT,  KC.UP,   KC.RSFT, KC.NO, KC.MEDIA_PLAY_PAUSE,
        KC.LCTL,   KC.LALT, KC.LGUI, KC.SPC,  KC.LEFT, KC.DOWN, KC.RIGHT, numero_dos,   KC.NO,   KC.NO,   KC.NO,   KC.NO,   KC.NO,   KC.NO,
    ],
]

if __name__ == '__main__':
    keyboard.go()

## Commit log

2025-06-05 added journal
2025-06-05 journaled: day-1
2025-06-08 add PCB
2025-06-08 save files locally
2025-06-09 journal: day-3
2025-06-10 added final case: cad
2025-06-10 Added PCB
2025-06-10 journaled: day-4
2025-06-10 added assets
2025-06-11 added readme and bom
2025-06-11 added bom.csv
2025-06-11 updated bom
2025-06-11 add total time
2025-06-12 added template firmware
2025-06-12 added RE and LED firmware
2025-06-16 make case 5° inclined
2025-06-18 updated bom to include 3rd party printing
2025-07-04 added firmware
2025-07-04 updated firmware
2025-07-05 added backtick
2025-07-07 added stuff
2025-07-07 fix incorrect order
2025-07-24 minor tweak to firmware
